# Keil uVision project TOUCH.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TOUCH +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,LV_CONF_INCLUDE_SIMPLE
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4xx_HAL_Driver\inc;..\USER\LED;..\USER\LCD;..\USER\BEEP;..\USER\KEY;..\USER\LCD;..\USER\TOUCH;..\USER\USART;..\USER\LOG;..\TEST;..\LVGL;..\LVGL\src;..\LVGL\src\drivers\display\ili9341;..\LVGL\src\drivers\display\lcd;..\GUI;..\SEGGER_RTT;..\SEGGER_RTT\RTT
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c stm32f4xx_hal_msp.c startup_stm32f407xx.s cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm4.h mpu_armv7.h
  group USER
    ../USER/LED/: led.c
    ../USER/BEEP/: beep.c
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/TOUCH/: ft5426.c touch.c xpt2046.c
    ../USER/USART/: usart.c
    ../USER/LOG/: log.c
    ../TEST/: test_log.c
    ../: lv_conf.h
  group STM32F4_HAL_FWLIB
    ../STM32F4xx_HAL_Driver/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c
  group Common
    ../Common/: common.c
  group GUI
    ../GUI/: gui_driver.c
  group LVGL
    ../LVGL/src/: lv_init.c
    ../LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../LVGL/src/display/: lv_display.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../LVGL/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../LVGL/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../LVGL/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../LVGL/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../LVGL/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../LVGL/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../LVGL/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../LVGL/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../LVGL/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../LVGL/src/draw/opengles/: lv_draw_opengles.c
    ../LVGL/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../LVGL/src/draw/sdl/: lv_draw_sdl.c
    ../LVGL/src/draw/snapshot/: lv_snapshot.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../LVGL/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../LVGL/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../LVGL/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../LVGL/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../LVGL/src/drivers/display/fb/: lv_linux_fbdev.c
    ../LVGL/src/drivers/display/ft81x/: lv_ft81x.c
    ../LVGL/src/drivers/display/ili9341/: lv_ili9341.c
    ../LVGL/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../LVGL/src/drivers/display/nv3007/: lv_nv3007.c
    ../LVGL/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../LVGL/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../LVGL/src/drivers/display/st7735/: lv_st7735.c
    ../LVGL/src/drivers/display/st7789/: lv_st7789.c
    ../LVGL/src/drivers/display/st7796/: lv_st7796.c
    ../LVGL/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../LVGL/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../LVGL/src/drivers/evdev/: lv_evdev.c
    ../LVGL/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../LVGL/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../LVGL/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../LVGL/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../LVGL/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../LVGL/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../LVGL/src/drivers/qnx/: lv_qnx.c
    ../LVGL/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../LVGL/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../LVGL/src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
    ../LVGL/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../LVGL/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../LVGL/src/font/binfont_loader/: lv_binfont_loader.c
    ../LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../LVGL/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../LVGL/src/font/imgfont/: lv_imgfont.c
    ../LVGL/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../LVGL/src/layouts/: lv_layout.c
    ../LVGL/src/layouts/flex/: lv_flex.c
    ../LVGL/src/layouts/grid/: lv_grid.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../LVGL/src/others/file_explorer/: lv_file_explorer.c
    ../LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/src/others/translation/: lv_translation.c
    ../LVGL/src/stdlib/: lv_mem.c
    ../LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../LVGL/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../LVGL/src/themes/: lv_theme.c
    ../LVGL/src/themes/default/: lv_theme_default.c
    ../LVGL/src/themes/mono/: lv_theme_mono.c
    ../LVGL/src/themes/simple/: lv_theme_simple.c
    ../LVGL/src/tick/: lv_tick.c
    ../LVGL/src/widgets/3dtexture/: lv_3dtexture.c
    ../LVGL/src/widgets/animimage/: lv_animimage.c
    ../LVGL/src/widgets/arc/: lv_arc.c
    ../LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../LVGL/src/widgets/bar/: lv_bar.c
    ../LVGL/src/widgets/button/: lv_button.c
    ../LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/widgets/canvas/: lv_canvas.c
    ../LVGL/src/widgets/chart/: lv_chart.c
    ../LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../LVGL/src/widgets/gif/: lv_gif.c
    ../LVGL/src/widgets/image/: lv_image.c
    ../LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../LVGL/src/widgets/ime/: lv_ime_pinyin.c
    ../LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/widgets/label/: lv_label.c
    ../LVGL/src/widgets/led/: lv_led.c
    ../LVGL/src/widgets/line/: lv_line.c
    ../LVGL/src/widgets/list/: lv_list.c
    ../LVGL/src/widgets/lottie/: lv_lottie.c
    ../LVGL/src/widgets/menu/: lv_menu.c
    ../LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../LVGL/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../LVGL/src/widgets/roller/: lv_roller.c
    ../LVGL/src/widgets/scale/: lv_scale.c
    ../LVGL/src/widgets/slider/: lv_slider.c
    ../LVGL/src/widgets/span/: lv_span.c
    ../LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/widgets/spinner/: lv_spinner.c
    ../LVGL/src/widgets/switch/: lv_switch.c
    ../LVGL/src/widgets/table/: lv_table.c
    ../LVGL/src/widgets/tabview/: lv_tabview.c
    ../LVGL/src/widgets/textarea/: lv_textarea.c
    ../LVGL/src/widgets/tileview/: lv_tileview.c
    ../LVGL/src/widgets/win/: lv_win.c
    ../LVGL/src/libs/bin_decoder/: lv_bin_decoder.c
    ../LVGL/src/osal/: lv_os.c
  group SEGGER_RTT
    ../SEGGER_RTT/RTT/: SEGGER_RTT.c
software components: CMSIS:CORE 4.3.0
